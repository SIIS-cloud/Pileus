## difc-kernel/pileus-kernel/security/difc/Kconfig
```kconfig
config SECURITY_DIFC
	bool "difc support"
	depends on SECURITY
	default n
	help
		This selects DIFC
```
